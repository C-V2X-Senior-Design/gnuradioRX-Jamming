options:
  parameters:
    author: dragon
    generate_options: qt_gui
    id: receive
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '50000'
    step: '100000'
    stop: '5000000'
    value: '1165000'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '5915000000'
    step: '100000'
    stop: '5918000000'
    value: '5916500000'
  states: {}
- name: ifgain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '10'
    step: '1'
    stop: '150'
    value: '100'
  states: {}
- name: rfgain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '10'
    step: '1'
    stop: '150'
    value: '98'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-100'
    step: '.1'
    stop: '-1'
    value: '-8.5'
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /media/dragon/Extreme SSD/collections/jammer.data
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /media/dragon/Extreme SSD/collections/transmit.data
    type: complex
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    bw0: bandwidth
    freq0: center_freq
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: ifgain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '5000000'
    fc: '5916500000'
    fftsize: 1024 * 2
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: bandwidth
    center_freq0: center_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rfgain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', blocks_file_sink_0, '0']
- [analog_simple_squelch_cc_0, '0', blocks_file_sink_0_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_const_sink_x_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', analog_simple_squelch_cc_0, '0']
- [uhd_usrp_source_0, '0', analog_simple_squelch_cc_0, '0']

metadata:
  file_format: 1
